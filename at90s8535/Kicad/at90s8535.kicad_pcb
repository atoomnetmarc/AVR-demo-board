# Repository atoomnetmarc/AVR-demo-board (continued)

## KiCad design at90s2323/Kicad/at90s2323.kicad_pcb (continued)

Board: 2 copper layers, 99.1 x 99.1 mm, 171 parts (3 on the bottom side), 54 nets.

## Code that names these connections

File at90s1200/Firmware/Reaction Time Game/include/define.h:

/*

Copyright 2024 Marc Ketel
SPDX-License-Identifier: Apache-2.0

*/

#ifndef define_H
#define define_H

#define LEDPORT PORTB
#define LEDPIN  PINB
#define LEDDDR  DDRB
#define LED1R   PB2
#define LED1G   PB3
#define LED1B   PB4
#define LED2R   PB5
#define LED2G   PB6
#define LED2B   PB7

#define BUTTONDDR DDRD
#define BUTTONPORT PORTD
#define BUTTONPIN PIND
#define BUTTON1 PD2
#define BUTTON2 PD3

#define LOOPDEBUGDDR  DDRD
#define LOOPDEBUGPORT PORTD
#define LOOPDEBUG     PD0

#define TIMERDEBUGDDR  DDRD
#define TIMERDEBUGPORT PORTD
#define TIMERDEBUG     PD1

// Registers shared by ISR and program.
#define event r16
#define random r0

// Registers used by program.
#define temp1 r17
#define temp2 r18
#define game_state_current r1
#define game_state_next r2
#define game_timer r3

// Registers used by ISR.
#define isr_S r4
#define isr_temp r19
#define isr_button r20
#define isr_counter_1ms r5
#define isr_counter_100ms r6

// List of events that could happen at the same time in the event register.
#define EV_1ms 0
#define EV_100ms 1
#define EV_BUTTON1 2
#define EV_BUTTON2 3

// List of game states
#define GS_START 0
#define GS_WAIT 1
#define GS_LED_CHANGE 2
#define GS_PLAYER_WAIT 3
#define GS_WIN_NOBODY 4
#define GS_WIN_PLAYER1 5
#define GS_WIN_PLAYER2 6
#define GS_WIN_BOTH 7
#define GS_END 8
#define GS_END_WAIT 9

#endif

## Commit log

2021-11-12 Add VSCode project to program at90s1200 in assembler.
2021-11-13 Add at90s2313 to blink project.
2021-11-13 Update readme.
2021-11-13 More better readme update.
2021-11-13 Add 3d printable presentation stand for demo board.
2021-12-26 Convert to Kicad 6
2021-12-26 Kicad 6 ERC fixes.
2022-07-01 Game of life.
2023-03-18 ATmega*8 has dW on PC6.
2023-03-18 ATtiny*8 has dW on PC6.
2023-03-25 Added ATmega8515 to pin overview.
2023-04-07 Add AT90S8535 demo board.
2023-04-18 Exclude mounting holes from BOM.
2023-04-18 Exclude solder jumper from BOM.
2023-05-20 Change LED R from 1k to 10k.
2023-05-20 AT90S8535 board has been made real.
2024-01-13 Correct part number for 5V to 3V level translation.
2024-02-08 Add PDF schematic.
2024-02-11 More ignore.
2024-02-11 Add info about programming the at90s1200 with avrdude.
2024-02-11 avrdude: "safemode" feature no longer supported
2024-02-11 Add ATtiny2313.
2024-02-11 Update dead link.
2024-02-12 Add Microchip Studio project file for assembly debug.
2024-02-12 Add more debug information (for .lss file).
2024-02-12 Corrected link to avrfreaks forum about WinAVR on Windows 10.
2024-02-15 Redraw schematic to contain actual schema instead of only labels. Kicad upgrade. No change to board.
2024-02-16 Add 'Reaction Time Game' for at90s1200 and pin-compatible parts.
2024-10-04 No change. Upgrade to Kicad 8.
2025-03-27 Cleanup platformio.ini
