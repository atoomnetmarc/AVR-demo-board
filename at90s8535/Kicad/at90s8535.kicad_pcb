# Repository atoomnetmarc/AVR-demo-board (continued)

## KiCad design at90s1200/Kicad/at90s1200.kicad_pcb

Parts:
C1, C2: 15pF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3: 100uF 16V; CP_Radial_D6.3mm_P2.50mm
C4: 33uF 16V; CP_Radial_D6.3mm_P2.50mm
C5, C6, C7: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1: 1N5819; D_DO-15_P12.70mm_Horizontal
D2: green; LED_D5.0mm
D3, D4: LED_BCRG; LED_D5.0mm-4_RGB
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
J1: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
J2: Barrel_Jack_Switch; BarrelJack_Horizontal
J3, J4: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Vertical
R1: 160R; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R2, R5: 620R; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R3, R6: 430R; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R4, R7: 360R; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R8, R9: 100R; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R10: 10k; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
SW1, SW2: SW_Push; SW_PUSH_6mm
U1: AT90S1200-12PC; DIP-20_W7.62mm_Socket_LongPads
U2: L7805; TO-220-3_Horizontal_TabDown
Y1: 8MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C4.1, C5.1, J1.2 (VCC), J4.10, R1.1, R10.1, U1.20 (VCC), U2.3 (OUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D2.1 (K), D3.2 (K), D4.2 (K), J1.4 (GND), J1.6 (GND), J1.8 (GND), J1.10 (GND), J2.2, J2.3, J3.10, SW1.2, SW2.2, U1.10 (GND), U2.2 (GND)
MISO: J1.9 (MISO), J4.8, R6.1, U1.18 (PB6)
MOSI: J1.1 (MOSI), J4.7, R5.1, U1.17 (PB5)
unnamed: D1.2 (A), J2.1
unnamed: C3.1, D1.1 (K), U2.1 (IN)
unnamed: D2.2 (A), R1.2
unnamed: D3.1 (BA), R4.2
unnamed: D3.4 (GA), R3.2
unnamed: D3.3 (RA), R2.2
unnamed: D4.1 (BA), R7.2
unnamed: D4.4 (GA), R6.2
unnamed: D4.3 (RA), R5.2
unnamed: R8.1, SW1.1
unnamed: R9.1, SW2.1
PB0: J4.2, U1.12 (PB0)
PB1: J4.3, U1.13 (PB1)
PB2: J4.4, R2.1, U1.14 (PB2)
PB3: J4.5, R3.1, U1.15 (PB3)
PB4: J4.6, R4.1, U1.16 (PB4)
PB6: J4.1, U1.11 (PD6)
PD0: J3.2, U1.2 (PD0)
PD1: J3.3, U1.3 (PD1)
PD2: C6.1, J3.6, R8.2, U1.6 (PD2)
PD3: C7.1, J3.7, R9.2, U1.7 (PD3)
PD4: J3.8, U1.8 (PD4)
PD5: J3.9, U1.9 (PD5)
SCK: J1.7 (SCK), J4.9, R7.1, U1.19 (PB7)
XTAL1: C1.1, J3.4, U1.4 (XTAL1), Y1.1
XTAL2: C2.1, J3.5, U1.5 (XTAL2), Y1.2
~RESET: J1.5 (~RST), J3.1, R10.2, U1.1 (~RESET)

Board: 2 copper layers, 99.1 x 99.1 mm, 34 parts (0 on the bottom side), 31 nets.

## KiCad design at90s2323/Kicad/at90s2323.kicad_pcb

Parts:
C1, C2: 15pF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3: 100uF 16V; CP_Radial_D6.3mm_P2.50mm
C4: 33uF 16V; CP_Radial_D6.3mm_P2.50mm
C5, C6, C7: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128: blue opaque; LED_D3.0mm_IRGrey
D129: 1N5819; D_DO-15_P5.08mm_Vertical_KathodeUp
D130: BAV99; SOT-23
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
J2: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
J3, J4: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 300R; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R17: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm
U1, U2: 74HC595; DIP-16_W7.62mm
U3: TPIC6B595; DIP-20_W7.62mm_LongPads
U4: L7805; TO-220-3_Horizontal_TabDown
U5: AT90S2323; DIP-8_W7.62mm
U6: MAX809M; SOT-23
Y1: 10MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, J2.2 (VCC), J4.4, R17.1, U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC), U3.2 (VCC), U3.8 (~SRCLR), U4.3 (OUT), U5.8 (VCC), U6.3 (VDD)
/C0: R1.1, U1.15 (QA)
/C1: R2.1, U1.1 (QB)
/C2: R3.1, U1.2 (QC)
/C3: R4.1, U1.3 (QD)
/C4: R5.1, U1.4 (QE)
/C5: R6.1, U1.5 (QF)
/C6: R7.1, U1.6 (QG)
/C7: R8.1, U1.7 (QH)
/C8: R9.1, U2.15 (QA)
/C9: R10.1, U2.1 (QB)
/C10: R11.1, U2.2 (QC)
/C11: R12.1, U2.3 (QD)
/C12: R13.1, U2.4 (QE)
/C13: R14.1, U2.5 (QF)
/C14: R15.1, U2.6 (QG)
/C15: R16.1, U2.7 (QH)
/R0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), U3.4 (DRAIN0)
/R1: D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), U3.5 (DRAIN1)
/R2: D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U3.6 (DRAIN2)
/R3: D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), U3.7 (DRAIN3)
/R4: D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K), U3.14 (DRAIN4)
/R5: D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), U3.15 (DRAIN5)
/R6: D97.1 (K), D98.1 (K), D99.1 (K), D100.1 (K), D101.1 (K), D102.1 (K), D103.1 (K), D104.1 (K), D105.1 (K), D106.1 (K), D107.1 (K), D108.1 (K), D109.1 (K), D110.1 (K), D111.1 (K), D112.1 (K), U3.16 (DRAIN6)
/R7: D113.1 (K), D114.1 (K), D115.1 (K), D116.1 (K), D117.1 (K), D118.1 (K), D119.1 (K), D120.1 (K), D121.1 (K), D122.1 (K), D123.1 (K), D124.1 (K), D125.1 (K), D126.1 (K), D127.1 (K), D128.1 (K), U3.17 (DRAIN7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.2, J1.3, J2.4 (GND), J2.6 (GND), J2.8 (GND), J2.10 (GND), J3.4, SW1.2, U1.8 (GND), U2.8 (GND), U3.1 (NC), U3.10 (GND), U3.11 (GND), U3.19 (GND), U3.20 (NC), U4.2 (GND), U5.4 (GND), U6.1 (GND)
unnamed: C3.1, D129.1 (K), U4.1 (IN)
unnamed: D1.2 (A), D17.2 (A), D33.2 (A), D49.2 (A), D65.2 (A), D81.2 (A), D97.2 (A), D113.2 (A), R1.2
unnamed: D10.2 (A), D26.2 (A), D42.2 (A), D58.2 (A), D74.2 (A), D90.2 (A), D106.2 (A), D122.2 (A), R10.2
unnamed: D4.2 (A), D20.2 (A), D36.2 (A), D52.2 (A), D68.2 (A), D84.2 (A), D100.2 (A), D116.2 (A), R4.2
unnamed: D5.2 (A), D21.2 (A), D37.2 (A), D53.2 (A), D69.2 (A), D85.2 (A), D101.2 (A), D117.2 (A), R5.2
unnamed: D6.2 (A), D22.2 (A), D38.2 (A), D54.2 (A), D70.2 (A), D86.2 (A), D102.2 (A), D118.2 (A), R6.2
unnamed: D7.2 (A), D23.2 (A), D39.2 (A), D55.2 (A), D71.2 (A), D87.2 (A), D103.2 (A), D119.2 (A), R7.2
unnamed: D8.2 (A), D24.2 (A), D40.2 (A), D56.2 (A), D72.2 (A), D88.2 (A), D104.2 (A), D120.2 (A), R8.2
unnamed: D9.2 (A), D25.2 (A), D41.2 (A), D57.2 (A), D73.2 (A), D89.2 (A), D105.2 (A), D121.2 (A), R9.2
unnamed: D11.2 (A), D27.2 (A), D43.2 (A), D59.2 (A), D75.2 (A), D91.2 (A), D107.2 (A), D123.2 (A), R11.2
unnamed: D12.2 (A), D28.2 (A), D44.2 (A), D60.2 (A), D76.2 (A), D92.2 (A), D108.2 (A), D124.2 (A), R12.2
unnamed: D13.2 (A), D29.2 (A), D45.2 (A), D61.2 (A), D77.2 (A), D93.2 (A), D109.2 (A), D125.2 (A), R13.2
unnamed: D14.2 (A), D30.2 (A), D46.2 (A), D62.2 (A), D78.2 (A), D94.2 (A), D110.2 (A), D126.2 (A), R14.2
unnamed: D15.2 (A), D31.2 (A), D47.2 (A), D63.2 (A), D79.2 (A), D95.2 (A), D111.2 (A), D127.2 (A), R15.2
unnamed: D16.2 (A), D32.2 (A), D48.2 (A), D64.2 (A), D80.2 (A), D96.2 (A), D112.2 (A), D128.2 (A), R16.2
unnamed: D2.2 (A), D18.2 (A), D34.2 (A), D50.2 (A), D66.2 (A), D82.2 (A), D98.2 (A), D114.2 (A), R2.2
unnamed: D3.2 (A), D19.2 (A), D35.2 (A), D51.2 (A), D67.2 (A), D83.2 (A), D99.2 (A), D115.2 (A), R3.2
unnamed: D129.2 (A), J1.1
unnamed: D130.1 (K), R18.2
unnamed: D130.3 (K), U6.2 (~RESET)
unnamed: U1.9 (QH'), U2.14 (SER)
unnamed: U1.14 (SER), U3.18 (SER_OUT)
PB0: J2.1 (MOSI), J4.1, U1.12 (RCLK), U1.13 (~OE), U2.12 (RCLK), U2.13 (~OE), U3.9 (~G), U3.12 (RCLK), U5.5 (MOSI/PB0)
PB1: J2.9 (MISO), J4.2, U3.3 (SER_IN), U5.6 (INT0/MISO/PB1)
PB2: J2.7 (SCK), J4.3, U1.11 (SRCLK), U2.11 (SRCLK), U3.13 (SRCK), U5.7 (T0/SCK/PB2)
XTAL1: C1.1, J3.2, U5.2 (XTAL1), Y1.1
XTAL2: C2.1, J3.3, U5.3 (XTAL2), Y1.2
~RESET: J2.5 (~RST), J3.1, R17.2, R18.1, SW1.1, U5.1 (~RESET)
