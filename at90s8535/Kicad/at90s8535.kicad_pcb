# Repository atoomnetmarc/AVR-demo-board

File README.md:

# AT90S1200

Demo board for the 20-pin AT90S1200 and AT90S2313 microcontroller.

Yes these chips are old, Arduino was not a thing back then. The AT90S1200 on the pcb is my first microcontroller I bought and programmed. It has a date code of 1998 week 40. I wrote software for it using AVR studio (4?) in assembler and programmed it using the [Handyman programmer and software made by Elektor](https://www.elektormagazine.com/magazine/elektor-199712/33974).

This AT90S1200 has only ever been used in breadboards, now about 20 years later it got its own PCB.

Like the silkscreen pinout? [Here](AVR%20overview.md) is a complete(-ish) overview of all know pin-compatible AT90S* microcontrollers and their pin functions.

# AT90S2323

The AT90S2323 is a 8-pin microcontroller with a whopping 3 I/O-pins. I believe this is the first 8-pin AVR.

One day I found some on eBay, bought them and proceeded to created this demo board to show its capabilities. I figured to control 128 LEDs with 3 I/O-pins. To expand de 3 I/O to drive 128 LEDs I used 3 shift registers in a 16x8 configuration. The shift registers however need 4 signals to drive them: DATA, CLK, RCLK and OE. When I tied RCLK and OE together I could bring that down to 3.

https://user-images.githubusercontent.com/48124268/116798381-1cadf400-aaef-11eb-9674-959b9dbc6236.mp4

# AT90S8535

The AT90S8535 belongs to the first 40-pin AVR microcontrollers from Atmel together with the AT90S8515. There also existed a 4K flash version of this chip, but that version seems to be only short lived, if at all.

This board breaks out all pins of the microcontroller into mostly PMOD compatible connectors. Mostly because if I understand correctly the voltage for PMOD IO and VCC should normally be at 3.3V. This board has both 5V and 3.3V PMOD connectors.

All pin-compatible microcontrollers will fit. When using a ATmega163 or newer, J8 is useable as a 5V I2C PMOD connector. When using a ATmega8535, J5 can be used as a 3.3V HW SPI PMOD port. When using ATmega323 or newer, EXP can be used as a JTAG connector.

On the back of the PCB there is a SOT-23 voltage monitor that functions as a BOD (brow out detector). Unlike newer parts, the AT90S8535 does not have a onboard BOD.

More information about this board: [README.md](at90s8535/README.md)

# Programming vintage AVRs in 2023

## Programmer

Make a [Arduino-as-ISP-shield](https://github.com/atoomnetmarc/Arduino-as-ISP-shield), then use AVRDUDE or [AVRDUDESS](https://blog.zakkemble.net/avrdudess-a-gui-for-avrdude/) to program the .hex file. This works under Windows 10.

AVRDUDE 6.3 is unable to program the AT90S2323 because it wrongly assumes this chip is the same as a AT90S2343, but it is not. Edit avrdude.conf and add the contents of [avrdude-at90s2323.conf](avrdude-at90s2323.conf) to just below the AT90S2343 config. This new section is a copy of the AT90S2343 section with one change, the chip signature.

## AVR Studio 4.19

Use the ancient [AVR Studio v4.19.730](https://www.microchip.com/mplab/avr-support/avr-and-sam-downloads-archive) to compile programs for the old AT90S* AVR's.

To compile c-programs you can still use [WinAVR-20100110-install.exe](https://sourceforge.net/projects/winavr/files/WinAVR/20100110/) containing ~~an old~~ a mature GCC compiler versioned 4.3, but you need some to [fix some incompatibilities with Windows 10](https://www.avrfreaks.net/s/topic/a5C3l000000USrIEAW/t124726) in order to make it work.\
There is a simpler solution, just use an [updated GCC](https://blog.zakkemble.net/avr-gcc-builds/). This update contains GCC version 12 and works to compile programs for the old AT90S* chips in AVR Studio 4.19.

## Visual Studio Code + PlatformIO

I was pleasantly surprised to find out that compiling a c-program using VSCode and PlatformIO also is a viable option. See the firmware directory of the AT90S2323 for an example on how to configure PlatformIO or see [the PlatformIO example native-blink](https://github.com/platformio/platform-atmelavr/tree/develop/examples/native-blink).

It is also possible to program the AT90S1200 in VSCode with PlatformIO in assembler! Have a look at my PlatformIO [blink](at90s1200/Firmware/blink/) project. You could also program the ATtiny2313 with the same assembler (and some `#if defined` macros) and debug using Microchip Studio.

## KiCad design at90s8535/Kicad/at90s8535.kicad_pcb

File at90s8535/README.md:

# MightyCore

You could use [MightyCore](https://github.com/MCUdude/MightyCore) to program a supported MCU (ATmega8535, ATmega16, ATmega32, ATmega164, ATmega324, ATmega644 and ATmega1284) using Arduino IDE or PlatformIO.

To be useful as an Arduino board, you must first burn a bootloader using the Arduino IDE. Use the instructions from the [MightyCore GitHub page](https://github.com/MCUdude/MightyCore) to burn the bootloader.

Verify the bootloader burn by compiling the blink sketch and uploading it to the board using the [USB UART PMOD](https://github.com/atoomnetmarc/PMOD-USB-UART) (or your own compatible serial cable). After uploading LED D8 should blink.

# AT90S4434 or AT90S8535

These old MCUs do not have bootloader capability and are not supported by [MightyCore](https://github.com/MCUdude/MightyCore). Program these with a AVR programmer connected to the ISP header.

# ATmega163 or ATmega323

The ATmega163 and ATmega323 are also not supported by [MightyCore](https://github.com/MCUdude/MightyCore). These MCUs do contain bootloader capability but are not supported by [Optiboot](https://github.com/Optiboot/optiboot).

At this moment (2023-05) you can program these just like the AT90S8535 using the ISP header.

Parts:
C1, C2: 15pF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C5, C14: 100n; C_Disc_D5.0mm_W2.5mm_P2.50mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
R1, R7: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20, R21: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
U1: AT90S8535-8PC; DIP-40_W15.24mm
Y1: 8MHz; Crystal_HC49-U_Vertical

Connections:
MISO: U1.7 (PB6/MISO); also elsewhere on the board
MOSI: U1.6 (PB5/MOSI); also elsewhere on the board
unnamed: C14.1, U1.32 (AREF)
unnamed: C1.1, U1.13 (XTAL1), Y1.1
unnamed: C2.1, U1.12 (XTAL2), Y1.2
PA0: U1.40 (PA0/ADC0); also elsewhere on the board
PA1: U1.39 (PA1/ADC1); also elsewhere on the board
PA2: U1.38 (PA2/ADC2); also elsewhere on the board
PA3: U1.37 (PA3/ADC3); also elsewhere on the board
PA4: U1.36 (PA4/ADC4); also elsewhere on the board
PA5(SD_~CS): U1.35 (PA5/ADC5); also elsewhere on the board
PA6(FLASH_~CS): U1.34 (PA6/ADC6); also elsewhere on the board
PA7(TFT_~CS): U1.33 (PA7/ADC7); also elsewhere on the board
PB0(LED): U1.1 (PB0/T0); also elsewhere on the board
PB2(~INT-IO): U1.3 (PB2/AIN0); also elsewhere on the board
PB3(TFT_BL): U1.4 (PB3/AIN1); also elsewhere on the board
PC0(I2C_SCL): R21.2, U1.22 (PC0); also elsewhere on the board
PC1(I2C_SDA): R20.2, U1.23 (PC1); also elsewhere on the board
PC2(TCK): U1.24 (PC2); also elsewhere on the board
PC3(TMS): U1.25 (PC3); also elsewhere on the board
PC4(TDO): U1.26 (PC4); also elsewhere on the board
PC5(TDI): U1.27 (PC5); also elsewhere on the board
PC6(TFT_D~C): U1.28 (PC6/TOSC1); also elsewhere on the board
PC7(TFT_~RST): U1.29 (PC7/TOSC2); also elsewhere on the board
PD2(MISO2): U1.16 (PD2/INT0); also elsewhere on the board
PD3(MOSI2): U1.17 (PD3/INT1); also elsewhere on the board
PD4(SCK2): U1.18 (PD4/OC1B); also elsewhere on the board
PD5(OC1A): U1.19 (PD5/OC1A); also elsewhere on the board
PD6(ICP): U1.20 (PD6/ICP); also elsewhere on the board
PD7(OC2): U1.21 (PD7/OC2); also elsewhere on the board
RXD: U1.14 (PD0/RXD0); also elsewhere on the board
SCK: U1.8 (PB7/SCK); also elsewhere on the board
TXD: U1.15 (PD1/TXD0); also elsewhere on the board
~RESET: R1.2, U1.9 (~RESET); also elsewhere on the board

Notes on the sheet:
I2C pull-up resistors when >= ATmega163
Ye olde microcontroller.
This schematic also works for: AT90S4434 AT90S8535 ATmega163 ATmega8535 ATmega323 ATmega16 ATmega32 ATmega644 ATmega1284 ATmega164 ATmega324

Parts:
J5, J9: Pmod host SPI; PinSocket_1x06_P2.54mm_Horizontal
J10: Pmod host SPI; PinSocket_2x06_P2.54mm_Horizontal_Top_Bottom

Connections:
+3.3V: J5.6 (VCC), J9.6 (VCC), J10.6 (VCC), J10.12 (VCC); also elsewhere on the board
MISO_3V: J9.3 (MISO), J10.3 (MISO); also elsewhere on the board
MOSI_3V: J9.2 (MOSI), J10.2 (MOSI); also elsewhere on the board
PA5(SD_~CS)_3V: J10.9 (GPIO/~CS2); also elsewhere on the board
PA6(FLASH_~CS)_3V: J9.1 (~CS); also elsewhere on the board
PA7(TFT_~CS)_3V: J10.1 (~CS); also elsewhere on the board
PB3(TFT_BL)_3V: J10.10 (GPIO/~CS3); also elsewhere on the board
PC6(TFT_D~C)_3V: J10.7 (GPIO/~INT); also elsewhere on the board
PC7(TFT_~RST)_3V: J10.8 (GPIO/~RESET); also elsewhere on the board
PD2(MISO2)_3V: J5.3 (MISO); also elsewhere on the board
PD3(MOSI2)_3V: J5.2 (MOSI); also elsewhere on the board
PD4(SCK2)_3V: J5.4 (SCK); also elsewhere on the board
SCK_3V: J9.4 (SCK), J10.4 (SCK); also elsewhere on the board

Notes on the sheet:
Hardware SPI when >= ATmega8535 and using USART in SPI mode.
3.3V IO connectors.
Suggested use: SPI RAM.
These have PMOD pinouts and work on 3.3V.
Suggested use: TFT display with SD card.
Suggested use: SPI Flash.

Parts:
C3: 100uF 16V; CP_Radial_D6.3mm_P2.50mm
C4, C9: 33uF 16V; CP_Radial_D6.3mm_P2.50mm
D1: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal
J3: Barrel_Jack_Switch; BarrelJack_Horizontal
U2: L7805; TO-220-3_Horizontal_TabDown
U4: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3.3V: C9.1, U4.2 (VO); also elsewhere on the board
unnamed: D1.2 (A), J3.1
unnamed: C3.1, D1.1 (K), U2.1 (IN)

Notes on the sheet:
9V to 5V and 3V3 linear regulators.

Parts:
C17: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D8: Blue; LED_D3.0mm
D130: BAV99; SOT-23
J1: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical
J2: AVR-JTAG-10; IDC-Header_2x05_P2.54mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R16: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm
U6: MAX809M; SOT-23

Connections:
MISO: J1.1 (MISO); also elsewhere on the board
MOSI: J1.4 (MOSI); also elsewhere on the board
unnamed: D8.1 (K), R16.1
unnamed: C17.2, JP1.1 (A)
PB0(LED): D8.2 (A); also elsewhere on the board
PC2(TCK): J2.1 (TCK); also elsewhere on the board
PC3(TMS): J2.5 (TMS); also elsewhere on the board
PC4(TDO): J2.3 (TDO); also elsewhere on the board
PC5(TDI): J2.9 (TDI); also elsewhere on the board
SCK: J1.3 (SCK); also elsewhere on the board
~CTS: C17.1; also elsewhere on the board
~RESET: J1.5 (~RST), J2.6 (~SRST), JP1.2 (B), SW1.2; also elsewhere on the board

Notes on the sheet:
Open JP1 to disable auto reset.
Programming & debug headers.
Reset button and auto reset programming.
Voltage monitor.
Only needed for devices without BOD like AT90S4434 or AT90S8535
Blinkenlight.
JTAG debug works for ATmega16 and newer. AT90S4434, AT90S8535, ATmega163 and ATmega8535 do not have JTAG port.

Parts:
C7, C8, C11, C18: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U3, U6, U11: 74AHC125D; SOIC-14_3.9x8.7mm_P1.27mm
U8: 74AHCT125D; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3.3V: C7.1, C8.1, C18.1, U3.14 (VCC), U6.14 (VCC), U11.14 (VCC); also elsewhere on the board
MISO: U8.3; also elsewhere on the board
MISO_3V: U8.2; also elsewhere on the board
MOSI: U3.5; also elsewhere on the board
MOSI_3V: U3.6; also elsewhere on the board
PA5(SD_~CS): U3.12; also elsewhere on the board
PA5(SD_~CS)_3V: U3.11; also elsewhere on the board
PA6(FLASH_~CS): U3.2; also elsewhere on the board
PA6(FLASH_~CS)_3V: U3.3; also elsewhere on the board
PA7(TFT_~CS): U11.12; also elsewhere on the board
PA7(TFT_~CS)_3V: U11.11; also elsewhere on the board
PB3(TFT_BL): U11.9; also elsewhere on the board
PB3(TFT_BL)_3V: U11.8; also elsewhere on the board
PC6(TFT_D~C): U11.2; also elsewhere on the board
PC6(TFT_D~C)_3V: U11.3; also elsewhere on the board
PC7(TFT_~RST): U11.5; also elsewhere on the board
PC7(TFT_~RST)_3V: U11.6; also elsewhere on the board
PD2(MISO2): U8.6; also elsewhere on the board
PD2(MISO2)_3V: U8.5; also elsewhere on the board
PD3(MOSI2): U6.9; also elsewhere on the board
PD3(MOSI2)_3V: U6.8; also elsewhere on the board
PD4(SCK2): U6.5; also elsewhere on the board
PD4(SCK2)_3V: U6.6; also elsewhere on the board
SCK: U3.9; also elsewhere on the board
SCK_3V: U3.8; also elsewhere on the board

Notes on the sheet:
Level translate 5V to 3V3.
Level translate 3V3 to 5V.

Parts:
J4: Pmod host UART; PinSocket_1x06_P2.54mm_Horizontal
J6: Pmod host I2C; PinSocket_1x06_P2.54mm_Horizontal
J7, J8: Pmod host GPIO; PinSocket_1x06_P2.54mm_Horizontal

Connections:
PA0: J8.3 (IO3); also elsewhere on the board
PA1: J8.4 (IO4); also elsewhere on the board
PA2: J7.1 (IO1); also elsewhere on the board
PA3: J7.3 (IO3); also elsewhere on the board
PA4: J6.2 (NC/~RESET); also elsewhere on the board
PB0(LED): J7.4 (IO4); also elsewhere on the board
PB2(~INT-IO): J6.1 (NC/~INT); also elsewhere on the board
PC0(I2C_SCL): J6.3 (SCL); also elsewhere on the board
PC1(I2C_SDA): J6.4 (SDA); also elsewhere on the board
PD5(OC1A): J7.2 (IO2/PWM); also elsewhere on the board
PD6(ICP): J8.1 (IO1); also elsewhere on the board
PD7(OC2): J8.2 (IO2/PWM); also elsewhere on the board
RXD: J4.3 (RXD); also elsewhere on the board
TXD: J4.2 (TXD); also elsewhere on the board
~CTS: J4.1 (~CTS/IO); also elsewhere on the board

Notes on the sheet:
5V IO connectors.
Suggested use: Mono PWM audio or SPI DAC. Be aware when using PB0 as input, has LED connected.
Suggested use: USB serial converter.
These have PMOD pinouts. Except they work with 5V VCC and 5V IO.
Suggested use: Yes! Use it. May be for user input?
Suggested use: I2C when supported by microcontroller.

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
Board: 2 copper layers, 99.1 x 99.1 mm, 46 parts (19 on the bottom side), 59 nets.

Other parts of the board:
D4: BAV99; SOT-23
R8: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U5: MAX809M; SOT-23

Their connections:
unnamed: D4.1 (K), R8.2
~RESET: R8.1; also elsewhere on the board

Notices in the files:
README.md:
License: Apache 2.0
at90s1200/Kicad/at90s1200.kicad_pcb:
Apache License, Version 2.0
